# Keil uVision project slave_save.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: diplom +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
